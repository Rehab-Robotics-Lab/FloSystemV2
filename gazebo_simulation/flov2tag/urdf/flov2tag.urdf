Commit message: set model pos much higher

File: gazebo_simulation/flov2tag/urdf/flov2tag.urdf (robot description, URDF)
Before this commit: robot flov2tag, 12 links, 11 joints
Joints:
- joint base_joint: origin xyz=0.0 0.0 0.0 rpy=0 0 0 -> xyz=0.0 0.0 1 rpy=0 0 0
